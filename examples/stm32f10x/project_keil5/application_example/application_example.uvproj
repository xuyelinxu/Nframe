# Keil uVision project application_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\library\CMSIS;..\..\library\stm32f10x;..\..\library\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\nframe\inc;..\..\application_example;..\..\..\..\component\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../../library/CMSIS/: core_cm3.c
  group startup
    ../../startup_armcc/: startup_stm32f10x_hd.s
    ../../library/stm32f10x/: system_stm32f10x.c
  group stm32f10x_std_lib
    ../../library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_rcc.c stm32f10x_gpio.c
  group nframe
    ../../../../nframe/src/: nfdebug.c nftask.c nfmsg.c nffsm.c
  group component
    ../../../../component/src/: nkeyscan.c
  group application_example
    ../../application_example/: main.c nframe_config.c app1fsm.c mainfsm.c keyboard.c
