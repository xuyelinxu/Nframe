# Keil uVision project example.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\library\CMSIS;..\library\stm32f10x;..\library\STM32F10x_StdPeriph_Driver\inc;..\user;..\..\..\nframe\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../library/CMSIS/: core_cm3.c
  group startup
    ../startup_armcc/: startup_stm32f10x_hd.s
    ../library/stm32f10x/: system_stm32f10x.c
  group stm32f10x_std_lib
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group nframe
    ../../../nframe/src/: nftask.c
  group user
    ../user/: nframe_config.c nftask_example.c
